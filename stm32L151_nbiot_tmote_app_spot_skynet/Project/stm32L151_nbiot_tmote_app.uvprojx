# Keil uVision project stm32L151_nbiot_tmote_app.uvprojx, settings and files
target stm32L151_nbiot_tmote_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151CC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32L151_nbiot_tmote_app +hex
  AfterMake: F:\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: cmd.exe /C copy  ..\Output\stm32L151_nbiot_tmote_app.bin  F:\Movebroad\stm32L151_nbiot\workspace\JFlash\stm32L151_nbiot_tmote_app_spot_skynet.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xC
  c include: ..\Core;..\HALLibraries\Inc;..\HALLibraries\Src;..\User;..\System\Sys;..\System\Delay;..\System\Usart;..\Libraries\Radar;..\Libraries\Inspect;..\Libraries\NBIot;..\Libraries\MQTTSNPacket\src;..\Libraries\MQTTSNPacket\mqttsn;..\Libraries\Radio;..\Libraries\Radio\radio_inc;..\Libraries\Radio\radio_src;..\Libraries\Radio\si446x_inc;..\Libraries\Radio\si446x_src;..\Libraries\Xtea;..\Libraries\RollingOver;..\Libraries\DnsClient;..\Libraries\UdpClient;..\Libraries\PCPUpgrade;..\Libraries\MQTTPCPUpgrade;..\Libraries\OneNET;..\Libraries\FifoMessage;..\Libraries\Sock;..\Hardware\RTC;..\Hardware\EEPROM;..\Hardware\IWDG;..\Hardware\IIC;..\Hardware\QMC5883L;..\Hardware\SWITCH;..\Hardware\VBAT;..\Hardware\VPTAT;..\Hardware\BEEP;..\Hardware\NET;..\Hardware\TEMPERATURE;..\Hardware\SPIFLASH;..\Hardware\TESTBENCH
  memory RVCT4: ROM 0x8003800 size 0x3c800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core
    ../Core/: startup_stm32l151xc.s cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group HALLibraries
    ../HALLibraries/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group Libraries
    ../Libraries/Xtea/: tmesh_xtea.lib
    ../Libraries/Inspect/: thingalgorithm_lib.lib
    ../Libraries/Radar/: tmesh_radar_algorithm.lib
  group Hardware
    ../Hardware/RTC/: hal_rtc.c
    ../Hardware/EEPROM/: hal_eeprom.c
    ../Hardware/IWDG/: hal_iwdg.c
    ../Hardware/BEEP/: hal_beep.c
    ../Hardware/SWITCH/: hal_switch.c
    ../Hardware/VBAT/: hal_vbat.c
    ../Hardware/VPTAT/: hal_vptat.c
    ../Hardware/TEMPERATURE/: hal_temperature.c
    ../Hardware/IIC/: hal_iic.c
    ../Hardware/QMC5883L/: hal_qmc5883l.c
    ../Hardware/SPIFLASH/: hal_spiflash.c
    ../Hardware/TESTBENCH/: hal_testbench.c
  group System
    ../System/Sys/: sys.c
    ../System/Delay/: delay.c
    ../System/Usart/: usart.c
  group User
    ../User/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c stm32l1xx_config.c system_stm32l1xx.c platform_map.c platform_map.h platform_config.c platform_config.h
  group RollingOver
    ../Libraries/RollingOver/: rollingover.c
  group Inspect
    ../Libraries/Inspect/: inspectconfig.c inspectmessageoperate.c tmesh_algorithm.h
  group Radar
    ../Libraries/Radar/: radar_api.c radar_adc.c radar_dac.c radar_dma.c radar_timer.c tmesh_radar_algorithm.h
  group FifoMessage
    ../Libraries/FifoMessage/: fifomessage.c
  group Sock
    ../Libraries/Sock/: sock.c
  group NBIot
    ../Libraries/NBIot/: nbiotconfig.c nbiotfunc.c nbiottransport.c
  group PCPUpgrade
    ../Libraries/PCPUpgrade/: pcpconfig.c pcpfunc.c pcpupgrade.c pcptransport.c pcpcrccheck.c pcpsock.c
  group DnsClinet
    ../Libraries/DnsClient/: dnsconfig.c dnsfunc.c dnstransport.c
  group UdpClient
    ../Libraries/UdpClient/: udpconfig.c udpfunc.c udpprotocol.c udptransport.c
  group MqttSNLib
    ../Libraries/MQTTSNPacket/src/: MQTTSNConnectClient.c MQTTSNConnectServer.c MQTTSNDeserializePublish.c MQTTSNPacket.c MQTTSNSearchClient.c MQTTSNSearchServer.c MQTTSNSerializePublish.c MQTTSNSubscribeClient.c MQTTSNSubscribeServer.c MQTTSNUnsubscribeClient.c MQTTSNUnsubscribeServer.c
  group MqttSN
    ../Libraries/MQTTSNPacket/mqttsn/: mqttsnconfig.c mqttsnfunc.c mqttsntransport.c
  group MqttPCPUpgrade
    ../Libraries/MQTTPCPUpgrade/: mqttpcpconfig.c mqttpcpfunc.c mqttpcpupgrade.c mqttpcptransport.c mqttpcpcrccheck.c mqttpcpsock.c
  group OneNET
    ../Libraries/OneNET/: onenetconfig.c onenetfunc.c onenettransport.c
  group Net
    ../Hardware/NET/: net_coap_message_operate.c net_coap_app.c net_pcp_message_operate.c net_pcp_app.c net_onenet_message_operate.c net_onenet_app.c net_mqttsn_message_operate.c net_mqttsn_app.c net_mqttsn_pcp_message_operate.c net_mqttsn_pcp_app.c net_udp_message_operate.c net_udp_app.c net_dns_app.c net_nbiot_app.c
  group Radio
    ../Libraries/Radio/radio_src/: radio_rf_app.c radio_hal_rf.c radio.c radio_comm.c radio_hal.c radio_spi.c
    ../Libraries/Radio/si446x_src/: si446x_api_lib.c
  group Xtea
    ../Libraries/Xtea/: tmesh_xtea.h
  group Readme
    ../: README.md
