<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8L001_ook_tmote_app_lockctrl.ewp</path>
    </project>
    <batchBuild />
</workspace>
