# Keil uVision project stm32L151_nbiot_tmote_boot.uvprojx, settings and files
target stm32L151_nbiot_tmote_boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32L151_nbiot_tmote_boot +hex
  AfterMake: F:\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: cmd.exe /C copy  ..\Output\stm32L151_nbiot_tmote_boot.bin  F:\Movebroad\stm32L151_nbiot\workspace\JFlash\stm32L151_nbiot_tmote_boot_spot_udp.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ..\Core;..\HALLibraries\Inc;..\HALLibraries\Src;..\User;..\System\Sys;..\System\Delay;..\System\Usart;..\Hardware\config;..\Hardware\EEPROM;..\Hardware\IWDG;..\Hardware\NET;..\Hardware\Radio;..\Hardware\Radio\radio_inc;..\Hardware\Radio\radio_src;..\Hardware\RTC;..\Hardware\SPIFLASH
  memory RVCT4: ROM 0x8000000 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core
    ../Core/: startup_stm32l151xba.s cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group HALLibraries
    ../HALLibraries/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group Hardware
    ../Hardware/config/: tmesh_cfg.c
    ../Hardware/EEPROM/: hal_eeprom.c
    ../Hardware/IWDG/: hal_iwdg.c
    ../Hardware/NET/: tmesh_misc.c tmesh_net_utility.c
    ../Hardware/RTC/: hal_rtc.c
    ../Hardware/SPIFLASH/: hal_spiflash.c
  group System
    ../System/Sys/: sys.c
    ../System/Delay/: delay.c
    ../System/Usart/: usart.c
  group User
    ../User/: main.c boot.c iap.c stm32l1xx_config.c stm32l1xx_hal_msp.c stm32l1xx_it.c system_stm32l1xx.c
  group Radio
    ../Hardware/Radio/: hal_rf.c tmesh_rf_app.c ugrade.c
    ../Hardware/Radio/radio_src/: radio.c radio_comm.c radio_hal.c radio_spi.c si446x_api_lib.c
  group Readme
    ../Doc/: Readme.txt
