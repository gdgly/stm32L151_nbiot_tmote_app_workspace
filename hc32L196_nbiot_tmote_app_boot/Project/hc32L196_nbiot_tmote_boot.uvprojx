# Keil uVision project hc32L196_nbiot_tmote_boot.uvprojx, settings and files
target hc32L196_nbiot_tmote_boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L196JCTA HDSC
  pack: HDSC.HC32L19X.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hc32L196_nbiot_tmote_boot +hex
  AfterMake: F:\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: cmd.exe /C copy  ..\Output\hc32L196_nbiot_tmote_boot.bin  F:\Movebroad\stm32L151_nbiot\workspace\JFlash\hc32L196_nbiot_tmote_boot.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Core;..\HALLibraries\inc;..\HALLibraries\src;..\User;..\System\Sys;..\System\Delay;..\System\Usart
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group Core
    ../Core/: startup_hc32l19x.s
  group HALLibraries
    ../HALLibraries/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group System
    ../System/Sys/: sys.c
    ../System/Delay/: delay.c
    ../System/Usart/: usart.c
  group User
    ../User/: main.c system_hc32l19x.c interrupts_hc32l19x.c hc32l19x_it.c hc32l19x_hal.c hc32l19x_config.c platform_map.c platform_map.h platform_config.c platform_config.h
  group Readme
    ../: README.md
software components: CMSIS:CORE 5.3.0
