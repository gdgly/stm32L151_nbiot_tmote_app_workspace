# Keil uVision project hc32L196_nbiot_tmote_app.uvprojx, settings and files
target hc32L196_nbiot_tmote_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L196JCTA HDSC
  pack: HDSC.HC32L19X.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hc32L196_nbiot_tmote_app +hex
  AfterMake: F:\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: cmd.exe /C copy  ..\Output\hc32L196_nbiot_tmote_app.bin  F:\Movebroad\stm32L151_nbiot\workspace\JFlash\hc32L196_nbiot_tmote_app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Core;..\HALLibraries\inc;..\HALLibraries\src;..\User;..\System\Sys;..\System\Delay;..\System\Usart;..\Hardware\IWDG;..\Hardware\RTC;..\Hardware\BEEP;..\Hardware\VBAT;..\Hardware\VPTAT;..\Hardware\VTEMP;..\Hardware\AES;..\Hardware\CRC;..\Hardware\FLASH;..\Hardware\IIC;..\Hardware\BL24CXXP;..\Hardware\EEPROM;..\Hardware\QMC5883L;..\Hardware\SPI;..\Hardware\P25QXXH;..\Hardware\NORFLASH;..\Libraries\FifoMessage;..\Libraries\Radio\radio_inc;..\Libraries\Radio\radio_src;..\Libraries\Radio\si446x_inc;..\Libraries\Radio\si446x_src;..\Libraries\Radio;..\Libraries\Fota
  library: MicroLIB
  memory RVCT4: ROM 0x7800 size 0x38800
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group Core
    ../Core/: startup_hc32l19x.s
  group HALLibraries
    ../HALLibraries/src/: adc.c adt.c aes.c bgr.c bt.c crc.c dac.c ddl.c debug.c dmac.c flash.c gpio.c i2c.c lcd.c lpm.c lptim.c lpuart.c lvd.c opa.c pca.c pcnt.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trim.c trng.c uart.c vc.c wdt.c
  group Hardware
    ../Hardware/IWDG/: hal_iwdg.c
    ../Hardware/RTC/: hal_rtc.c
    ../Hardware/BEEP/: hal_beep.c
    ../Hardware/VBAT/: hal_vbat.c
    ../Hardware/VPTAT/: hal_vptat.c
    ../Hardware/VTEMP/: hal_vtemp.c
    ../Hardware/AES/: hal_aes.c
    ../Hardware/CRC/: hal_crc.c
    ../Hardware/FLASH/: hal_flash.c
    ../Hardware/IIC/: hal_iic.c
    ../Hardware/BL24CXXP/: hal_bl24cxxp.c
    ../Hardware/EEPROM/: hal_eeprom.c
    ../Hardware/QMC5883L/: hal_qmc5883l.c
    ../Hardware/SPI/: hal_spi.c
    ../Hardware/P25QXXH/: hal_p25qxxh.c
    ../Hardware/NORFLASH/: hal_norflash.c
  group System
    ../System/Sys/: sys.c
    ../System/Delay/: delay.c
    ../System/Usart/: usart.c
  group User
    ../User/: main.c system_hc32l19x.c interrupts_hc32l19x.c hc32l19x_it.c hc32l19x_hal.c hc32l19x_config.c platform_map.c platform_map.h platform_config.c platform_config.h
  group FifoMessage
    ../Libraries/FifoMessage/: fifo.c message.c
  group Radio
    ../Libraries/Radio/radio_src/: radio_hal_wrap.c radio_hal_spi.c radio_core.c radio_comm.c
    ../Libraries/Radio/si446x_src/: si446x_api_lib.c
  group Fota
    ../Libraries/Fota/: fota.c
  group Readme
    ../: README.md
software components: CMSIS:CORE 5.3.0
